# Keil uVision project 123.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: 123
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c adc.c dight.c port.c sysclk.c time.c lcd.c queue.c
